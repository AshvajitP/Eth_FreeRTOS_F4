# IAR project Eth_FreeRTOS_F4.ewp, settings and files
configuration Eth_FreeRTOS_F4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\ThirdParty\FreeRTOS\include; ..\ThirdParty\FreeRTOS\portable; ..\ThirdParty\FreeRTOS\portable\MemMang; ..\ThirdParty\FreeRTOSplus\include; ..\ThirdParty\FreeRTOSplus\portable\BufferManagement; ..\ThirdParty\FreeRTOSplus\portable\Compiler\IAR; ..\ThirdParty\FreeRTOSplus\portable\NetworkInterface; ..\ThirdParty\coreHTTP; ..\ThirdParty\coreHTTP\include; ..\ThirdParty\coreHTTP\interface; ..\ThirdParty\coreHTTP\dependency\include; ..\ThirdParty\coreHTTP\dependency\src; ..\ThirdParty\FreeRTOSplus\network_transport; ..\ThirdParty\FreeRTOSplus\network_transport\tcp_sockets_wrapper; ..\ThirdParty\FreeRTOSplus\network_transport\tcp_sockets_wrapper\include; ..\ThirdParty\certificate; ..\ThirdParty\mbedtls\library; ..\ThirdParty\mbedtls\include; ..\ThirdParty\mbedtls\tests\include\alt-dummy
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: Eth_FreeRTOS_F4.hex
  ILINK.IlinkOutputFile: Eth_FreeRTOS_F4.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: hardware_rng.c Http_Open.c main.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group ThirdParty/certificate
    ../ThirdParty/certificate/: tls_cert.crt
  group ThirdParty/coreHTTP
    ../ThirdParty/coreHTTP/: core_http_client.c
  group ThirdParty/coreHTTP/dependency/include
    ../ThirdParty/coreHTTP/dependency/include/: llhttp.h
  group ThirdParty/coreHTTP/dependency/src
    ../ThirdParty/coreHTTP/dependency/src/: api.c http.c llhttp.c
  group ThirdParty/coreHTTP/include
    ../ThirdParty/coreHTTP/include/: core_http_client.h core_http_client_private.h core_http_config_defaults.h
  group ThirdParty/coreHTTP/interface
    ../ThirdParty/coreHTTP/interface/: transport_interface.h
  group ThirdParty/FreeRTOS
    ../ThirdParty/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group ThirdParty/FreeRTOS/include
    ../ThirdParty/FreeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group ThirdParty/FreeRTOS/portable
    ../ThirdParty/FreeRTOS/portable/: port.c port_proto.h portasm.s portmacro.h
  group ThirdParty/FreeRTOS/portable/MemMang
    ../ThirdParty/FreeRTOS/portable/MemMang/: heap_4.c
  group ThirdParty/FreeRTOSplus
    ../ThirdParty/FreeRTOSplus/: FreeRTOS_ARP.c FreeRTOS_BitConfig.c FreeRTOS_DHCP.c FreeRTOS_DHCPv6.c FreeRTOS_DNS.c FreeRTOS_DNS_Cache.c FreeRTOS_DNS_Callback.c FreeRTOS_DNS_Networking.c FreeRTOS_DNS_Parser.c FreeRTOS_ICMP.c FreeRTOS_IP.c FreeRTOS_IP_Timers.c FreeRTOS_IP_Utils.c FreeRTOS_IPv4.c FreeRTOS_IPv4_Sockets.c FreeRTOS_IPv4_Utils.c FreeRTOS_IPv6.c FreeRTOS_IPv6_Sockets.c FreeRTOS_IPv6_Utils.c FreeRTOS_ND.c FreeRTOS_RA.c FreeRTOS_Routing.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_IP_IPv4.c FreeRTOS_TCP_IP_IPv6.c FreeRTOS_TCP_Reception.c FreeRTOS_TCP_State_Handling.c FreeRTOS_TCP_State_Handling_IPv4.c FreeRTOS_TCP_State_Handling_IPv6.c FreeRTOS_TCP_Transmission.c FreeRTOS_TCP_Transmission_IPv4.c FreeRTOS_TCP_Transmission_IPv6.c FreeRTOS_TCP_Utils.c FreeRTOS_TCP_Utils_IPv4.c FreeRTOS_TCP_Utils_IPv6.c FreeRTOS_TCP_WIN.c FreeRTOS_Tiny_TCP.c FreeRTOS_UDP_IP.c FreeRTOS_UDP_IPv4.c FreeRTOS_UDP_IPv6.c
  group ThirdParty/FreeRTOSplus/include
    ../ThirdParty/FreeRTOSplus/include/: FreeRTOS_ARP.h FreeRTOS_BitConfig.h FreeRTOS_DHCP.h FreeRTOS_DHCPv6.h FreeRTOS_DNS.h FreeRTOS_DNS_Cache.h FreeRTOS_DNS_Callback.h FreeRTOS_DNS_Globals.h FreeRTOS_DNS_Networking.h FreeRTOS_DNS_Parser.h FreeRTOS_ICMP.h FreeRTOS_IP.h FreeRTOS_IP_Common.h FreeRTOS_IP_Private.h FreeRTOS_IP_Timers.h FreeRTOS_IP_Utils.h FreeRTOS_IPv4.h FreeRTOS_IPv4_Private.h FreeRTOS_IPv4_Sockets.h FreeRTOS_IPv4_Utils.h FreeRTOS_IPv6.h FreeRTOS_IPv6_Private.h FreeRTOS_IPv6_Sockets.h FreeRTOS_IPv6_Utils.h FreeRTOS_ND.h FreeRTOS_Routing.h FreeRTOS_Sockets.h FreeRTOS_Stream_Buffer.h FreeRTOS_TCP_IP.h FreeRTOS_TCP_Reception.h FreeRTOS_TCP_State_Handling.h FreeRTOS_TCP_Transmission.h FreeRTOS_TCP_Utils.h FreeRTOS_TCP_WIN.h FreeRTOS_UDP_IP.h FreeRTOSIPConfigDefaults.h FreeRTOSIPDeprecatedDefinitions.h IPTraceMacroDefaults.h NetworkBufferManagement.h NetworkInterface.h
  group ThirdParty/FreeRTOSplus/network_transport
    ../ThirdParty/FreeRTOSplus/network_transport/: mbedtls_bio_tcp_sockets_wrapper.c mbedtls_bio_tcp_sockets_wrapper.h transport_mbedtls.c transport_mbedtls.h transport_plaintext.c transport_plaintext.h
  group ThirdParty/FreeRTOSplus/network_transport/tcp_sockets_wrapper
    ../ThirdParty/FreeRTOSplus/network_transport/tcp_sockets_wrapper/: sockets_wrapper.c tcp_sockets_wrapper.c
  group ThirdParty/FreeRTOSplus/network_transport/tcp_sockets_wrapper/include
    ../ThirdParty/FreeRTOSplus/network_transport/tcp_sockets_wrapper/include/: sockets_wrapper.h tcp_sockets_wrapper.h
  group ThirdParty/FreeRTOSplus/portable/BufferManagement
    ../ThirdParty/FreeRTOSplus/portable/BufferManagement/: BufferAllocation_2.c
  group ThirdParty/FreeRTOSplus/portable/Compiler
    ../ThirdParty/FreeRTOSplus/portable/Compiler/IAR/: pack_struct_end.h pack_struct_start.h
  group ThirdParty/FreeRTOSplus/portable/NetworkInterface
    ../ThirdParty/FreeRTOSplus/portable/NetworkInterface/: NetworkInterface.c phyHandling.c phyHandling.h stm32f2xx_hal_eth.h stm32f4xx_hal_eth.h stm32f7xx_hal_eth.h stm32fxx_hal_eth.c stm32fxx_hal_eth.h
  group ThirdParty/mbedtls/include/mbedtls
    ../ThirdParty/mbedtls/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h bignum.h build_info.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cipher.h cmac.h compat-2.x.h config_adjust_legacy_crypto.h config_adjust_legacy_from_psa.h config_adjust_psa_from_legacy.h config_adjust_psa_superset_legacy.h config_adjust_ssl.h config_adjust_x509.h config_psa.h constant_time.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h error.h gcm.h hkdf.h hmac_drbg.h lms.h mbedtls_config.h md.h md5.h memory_buffer_alloc.h net_sockets.h nist_kw.h oid.h pem.h pk.h pkcs12.h pkcs5.h pkcs7.h platform.h platform_time.h platform_util.h poly1305.h private_access.h psa_util.h ripemd160.h rsa.h sha1.h sha256.h sha3.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h
  group ThirdParty/mbedtls/include/psa
    ../ThirdParty/mbedtls/include/psa/: build_info.h crypto.h crypto_adjust_auto_enabled.h crypto_adjust_config_key_pair_types.h crypto_adjust_config_synonyms.h crypto_builtin_composites.h crypto_builtin_key_derivation.h crypto_builtin_primitives.h crypto_compat.h crypto_config.h crypto_driver_common.h crypto_driver_contexts_composites.h crypto_driver_contexts_key_derivation.h crypto_driver_contexts_primitives.h crypto_extra.h crypto_legacy.h crypto_platform.h crypto_se_driver.h crypto_sizes.h crypto_struct.h crypto_types.h crypto_values.h
  group ThirdParty/mbedtls/library
    ../ThirdParty/mbedtls/library/: aes.c aesce.c aesce.h aesni.c aesni.h alignment.h aria.c asn1parse.c asn1write.c base64.c base64_internal.h bignum.c bignum_core.c bignum_core.h bignum_mod.c bignum_mod.h bignum_mod_raw.c bignum_mod_raw.h bignum_mod_raw_invasive.h bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c check_crypto_config.h cipher.c cipher_wrap.c cipher_wrap.h cmac.c common.h constant_time.c constant_time_impl.h constant_time_internal.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c ecp_curves_new.c ecp_internal_alt.h ecp_invasive.h entropy.c entropy_poll.c entropy_poll.h error.c gcm.c hkdf.c hmac_drbg.c lmots.c lmots.h lms.c md.c md5.c md_psa.h md_wrap.h memory_buffer_alloc.c mps_common.h mps_error.h mps_reader.c mps_reader.h mps_trace.c mps_trace.h net_sockets.c nist_kw.c oid.c padlock.c padlock.h pem.c pk.c pk_internal.h pk_wrap.c pk_wrap.h pkcs12.c pkcs5.c pkcs7.c pkparse.c pkwrite.c pkwrite.h platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_aead.h psa_crypto_cipher.c psa_crypto_cipher.h psa_crypto_client.c psa_crypto_core.h psa_crypto_core_common.h psa_crypto_driver_wrappers.h psa_crypto_driver_wrappers_no_static.c psa_crypto_driver_wrappers_no_static.h psa_crypto_ecp.c psa_crypto_ecp.h psa_crypto_ffdh.c psa_crypto_ffdh.h psa_crypto_hash.c psa_crypto_hash.h psa_crypto_invasive.h psa_crypto_its.h psa_crypto_mac.c psa_crypto_mac.h psa_crypto_pake.c psa_crypto_pake.h psa_crypto_random_impl.h psa_crypto_rsa.c psa_crypto_rsa.h psa_crypto_se.c psa_crypto_se.h psa_crypto_slot_management.c psa_crypto_slot_management.h psa_crypto_storage.c psa_crypto_storage.h psa_its_file.c psa_util.c psa_util_internal.h ripemd160.c rsa.c rsa_alt_helpers.c rsa_alt_helpers.h sha1.c sha256.c sha3.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_client.h ssl_cookie.c ssl_debug_helpers.h ssl_debug_helpers_generated.c ssl_misc.h ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_invasive.h ssl_tls13_keys.c ssl_tls13_keys.h ssl_tls13_server.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c
  group ThirdParty/mbedtls/test/include/alt-dummy
    ../ThirdParty/mbedtls/tests/include/alt-dummy/: threading_alt.h
