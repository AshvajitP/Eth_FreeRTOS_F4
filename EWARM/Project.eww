<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Eth_FreeRTOS_F4.ewp</path>
  </project>
  <batchBuild />
</workspace>
